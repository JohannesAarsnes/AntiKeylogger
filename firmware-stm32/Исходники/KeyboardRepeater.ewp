# IAR project KeyboardRepeater.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; CRC32_IEEE_802_3
  ICCARM.CCIncludePath2: ; source/; usblib/; auxiliary/; keyboard/; auxiliary/hal/Inc; auxiliary/hal/Inc/Legacy; auxiliary/middlewares/ST/STM32_USB_Device_Library/Core/Inc; auxiliary/middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; auxiliary/cmsis/Device/ST/STM32F1xx/Include; auxiliary/cmsis/Include; crypto/include/; crypto/binary/
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KeyboardRepeater.hex
  ILINK.IlinkOutputFile: KeyboardRepeater.out
  ILINK.IlinkIcfFile: source\stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group auxiliary/cmsis
    auxiliary/cmsis/: system_stm32f1xx.c
  group auxiliary/hal
    auxiliary/hal/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_usb.c
  group auxiliary/middlewares/usb
    auxiliary/middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    auxiliary/middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group crypto
    crypto/binary/: STM32CryptographicV3.0.0_CM3_IAR_otnsc.a
  group keyboard
    keyboard/: cycle_queue.c ps2_keyboard.c
  group source
    source/: crc.c custom_aes196cbc.c exchanger.c main.c startup_stm32f103xb.s stm32f103xb_flash.icf stm32f103xb_sram.icf stm32f1xx_hal_msp.c stm32f1xx_it.c
  group usblib
    usblib/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
